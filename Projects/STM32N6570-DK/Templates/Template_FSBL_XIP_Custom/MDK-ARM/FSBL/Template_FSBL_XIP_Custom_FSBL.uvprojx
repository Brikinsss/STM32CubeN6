# Keil uVision project Template_FSBL_XIP_Custom_FSBL.uvprojx, settings and files
target Template_FSBL_XIP_Custom_FSBL (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: IRAM(0x00000000,0x00040000) IRAM2(0x20000000,0x00040000) XRAM(0x24000000,0x3E0000) XRAM2(0x25000000,0x01000000) XRAM3(0x28000000,0x00008000) CPUTYPE("Cortex-M55") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Template_FSBL_XIP_Custom_FSBL
  AfterMake: fromelf.exe --bin Objects\Template_FSBL_XIP_Custom_FSBL.axf  --output ..\..\Binaries\Template_FSBL_XIP_Custom_FSBL.bin
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32N657xx,USE_HAL_DRIVER, DATATYPE, NO_OTP_FUSE,DEBUG_TRACE_NA
  c include: ../../FSBL/Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32N6570-DK;../../../../../../Middlewares/ST/STM32_ExtMem_Manager/boot;../../../../../../Middlewares/ST/STM32_ExtMem_Manager;..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Manager\custom
  library: MicroLIB
  memory RVCT4: ROM 0x34180400 size 0x3fc00
  memory RVCT6: RAM 0x24000000 size 0x3e0000
  memory RVCT7: RAM 0x25000000 size 0x1000000
  memory RVCT8: RAM 0x28000000 size 0x8000
  memory RVCT9: RAM 0x341c0000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x40000
  scatter file: .\stm32n657xx_axisram2_fsbl.sct
  link misc: --diag_suppress L6848W
  group Drivers/STM32N6xx_HAL_Drivers
    ../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_bsec.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_xspi.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../../FSBL/Src/: system_stm32n6xx_fsbl.c
  group Example/MDK-ARM
    ./: startup_stm32n657xx_fsbl.c
  group Example/User
    ../../FSBL/Src/: main.c stm32n6xx_hal_msp.c stm32n6xx_it.c extmem_manager.c
  group Middlewares/STM32_ExtMem_Manager/Boot
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/boot/: stm32_boot_xip.c
  group Middlewares/STM32_ExtMem_Manager/Custom
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/custom/: stm32_custom_driver.c
  group Middlewares/STM32_ExtMem_Manager
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/: stm32_extmem.c
  group Doc
    ../../: README.md
