# Keil uVision project Template_Isolation_XIP_ExtMemLoader.uvprojx, settings and files
target Template_Isolation_XIP_ExtMemLoader (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.0.1.3
  cpu: IRAM(0x00000000,0x00040000) IRAM2(0x20000000,0x00040000) XRAM(0x24000000,0x3E0000) XRAM2(0x25000000,0x01000000) XRAM3(0x28000000,0x00008000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: Template_Isolation_XIP_ExtMemLoader +hex
  AfterMake: cmd.exe /C copy "!L" "{STM32_PRG_PATH}\ExternalLoader\@L.stldr"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32N657xx,STM32_EXTMEMLOADER_STM32CUBETARGET
  c include: ../../ExtMemLoader/Inc;../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/ST/STM32_ExtMem_Loader;../../../../../../Middlewares/ST/STM32_ExtMem_Loader/core;../../../../../../Middlewares/ST/STM32_ExtMem_Loader/MDK-ARM;../../../../../../Middlewares/ST/STM32_ExtMem_Loader/STM32Cube;../../../../../../Middlewares/ST/STM32_ExtMem_Loader/EWARM ;../../../../../../Middlewares/ST/STM32_ExtMem_Manager;../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal;../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp;../../../../../../Middlewares/ST/STM32_ExtMem_Manager/boot;../../../../../../Middlewares/ST/STM32_ExtMem_Manager/psram;../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sdcard;../../../../../../Middlewares/ST/STM32_ExtMem_Manager/user;../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS\Device\ST\STM32N6xx\Include\Templates
  asm define: STM32_EXTMEMLOADER_STM32CUBETARGET
  memory RVCT6: RAM 0x24000000 size 0x3e0000
  memory RVCT7: RAM 0x25000000 size 0x1000000
  memory RVCT8: RAM 0x28000000 size 0x8000
  memory RVCT9: RAM 0x0 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x40000
  scatter file: .\stm32n6xx_extmemloader_stm32cube.sct
  group Drivers/STM32N6xx_HAL_Drivers
    ../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_bsec.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_xspi.c
  group Drivers/CMSIS
    ../../ExtMemLoader/Src/: system_stm32n6xx_fsbl.c
  group Application/User/ExtMemLoader
    ../../ExtMemLoader/Src/: extmem_manager.c extmemloader_init.c stm32n6xx_hal_msp.c
  group Middlewares/STM32_ExtMem_Manager
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/boot/: stm32_boot_xip.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp/: stm32_sfdp_data.c stm32_sfdp_driver.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/psram/: stm32_psram_driver.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal/: stm32_sal_xspi.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/: stm32_extmem.c
  group Middlewares/STM32_ExtMem_Loader
    ../../../../../../Middlewares/ST/STM32_ExtMem_Loader/core/: memory_wrapper.c systick_management.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Loader/MDK-ARM/: FlashDev.c FlashPrg.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Loader/STM32Cube/: stm32_device_info.c stm32_loader_api.c
software components: CMSIS:CORE 6.1.0
