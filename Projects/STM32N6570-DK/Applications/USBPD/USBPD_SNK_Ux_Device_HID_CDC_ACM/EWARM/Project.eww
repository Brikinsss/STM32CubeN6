<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\USBPD_SNK_Ux_Device_HID_CDC_ACM_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
