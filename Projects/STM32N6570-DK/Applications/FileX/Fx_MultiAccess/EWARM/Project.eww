<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\Fx_MultiAccess_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
