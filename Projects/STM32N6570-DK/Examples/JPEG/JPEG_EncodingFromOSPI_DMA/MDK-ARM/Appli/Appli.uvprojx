# Keil uVision project Appli.uvprojx, settings and files
target JPEG_EncodingFromOSPI_DMA_Appli (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: IRAM(0x341C0000-0x341FFFFF) IROM(0x34180400-0x341C03FF) CLOCK(8000000) FPU3(DFPU) CPUTYPE("Cortex-M55") ELITTLE TZ DSP
  output: Project +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32N657xx,USE_FULL_ASSERT
  c include: ../../Appli/Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../../../Drivers/BSP/STM32N6570-DK;../../../../../../../Utilities/JPEG
  memory RVCT4: ROM 0x70100400 size 0x1dfc00
  memory RVCT9: RAM 0x34000000 size 0x100000
  scatter file: .\stm32n657xx_ROMxspi2.sct
  group Application/MDK-ARM
    ../: startup_stm32n657xx.c
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c
  group Drivers/CMSIS
    ../../Appli/Src/: system_stm32n6xx_s.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_jpeg.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_exti.c
  group Example
    ../../Appli/Src/: main.c stm32n6xx_hal_msp.c stm32n6xx_it.c
  group User
    ../../Appli/Src/: encode_dma.c Image_argb_8888.c Image_rgb_565.c Image_rgb_888.c
  group Utilities
    ../../../../../../../Utilities/JPEG/: jpeg_utils.c
software components: CMSIS:CORE 5.6.0
