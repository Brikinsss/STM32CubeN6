# Keil uVision project BSP_FSBL.uvprojx, settings and files
target BSP_FSBL (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: IRAM(0x341C0000-0x341FFFFF) IROM(0x34180400-0x341C03FF) CLOCK(8000000) FPU3(DFPU) CPUTYPE("Cortex-M55") ELITTLE TZ DSP
  output: Project +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32N657xx
  c include: ../../FSBL/Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/STM32N6570-DK;../../../../../../Utilities/lcd;../../../../../../Utilities/Fonts;../../../../../../Drivers/BSP/Components/imx335;../../../../../../Drivers/BSP/Components/gt911;../../../../../../Middlewares/ST/STM32_ISP_Library/evision/Inc;../../../../../../Middlewares/ST/STM32_ISP_Library/isp/Inc;..\..\..\..\..\..\Middlewares\ST\STM32_ISP_Library\evision\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x34180400 size 0x3fc00
  memory RVCT9: RAM 0x341c0000 size 0x40000
  scatter file: stm32n657xx_axisram2_fsbl.sct
  group Application/MDK-ARM
    ../: startup_stm32n657xx_fsbl.c
  group Doc
    ../../: README.md
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/gt911/: gt911.c gt911_reg.c
    ../../../../../../Drivers/BSP/Components/imx335/: imx335.c imx335_reg.c
  group Drivers/BSP/STM32N6570-DK
    ../../../../../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c stm32n6570_discovery_bus.c stm32n6570_discovery_camera.c stm32n6570_discovery_lcd.c stm32n6570_discovery_sd.c stm32n6570_discovery_ts.c
  group Drivers/CMSIS
    ../../FSBL/Src/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_bsec.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dcmipp.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma2d.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_ltdc.c stm32n6xx_hal_ltdc_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_ramcfg.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_sd.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c stm32n6xx_ll_sdmmc.c
  group Example
    ../../FSBL/Src/: camera.c lcd.c main.c sd.c stm32n6xx_it.c touchscreen.c
  group Middlewares/STM32_ISP
    ../../../../../../Middlewares/ST/STM32_ISP_Library/isp/Src/: isp_algo.c isp_core.c isp_services.c
  group Middlewares/STM32_ISP/evision
    ../../../../../../Middlewares/ST/STM32_ISP_Library/evision/Lib/: libn6-evision-awb_keil.a libn6-evision-st-ae_keil.a
  group Utilities
    ../../../../../../Utilities/lcd/: stm32_lcd.c
software components: CMSIS:CORE 5.6.0
