<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\FSBL\BSP_FSBL.ewp</path>
    </project>
</workspace>
