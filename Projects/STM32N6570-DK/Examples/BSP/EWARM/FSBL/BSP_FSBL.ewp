# IAR project BSP_FSBL.ewp, settings and files
configuration BSP_FSBL (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx
  ICCARM.CCIncludePath2: ..\..\FSBL\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\..\..\..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\STM32N6570-DK; ..\..\..\..\..\..\Utilities\lcd; ..\..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\..\Drivers\BSP\Components\imx335; ..\..\..\..\..\..\Drivers\BSP\Components\gt911; ..\..\..\..\..\..\Middlewares\ST\STM32_ISP_Library\evision\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_ISP_Library\isp\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram2_fsbl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../../: README.md
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/gt911/: gt911.c gt911_reg.c
    ../../../../../../Drivers/BSP/Components/imx335/: imx335.c imx335_reg.c
  group Drivers/BSP/STM32N6570-DK
    ../../../../../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c stm32n6570_discovery_bus.c stm32n6570_discovery_camera.c stm32n6570_discovery_lcd.c stm32n6570_discovery_sd.c stm32n6570_discovery_ts.c
  group Drivers/CMSIS
    ../: startup_stm32n657xx_fsbl.s
    ../../FSBL/Src/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_bsec.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dcmipp.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma2d.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_ltdc.c stm32n6xx_hal_ltdc_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_ramcfg.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_sd.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c stm32n6xx_ll_sdmmc.c
  group Example
    ../../FSBL/Src/: camera.c lcd.c main.c sd.c stm32n6xx_it.c touchscreen.c
  group Middlewares/STM32_ISP
    ../../../../../../Middlewares/ST/STM32_ISP_Library/isp/Src/: isp_algo.c isp_core.c isp_services.c
  group Middlewares/STM32_ISP/evision
    ../../../../../../Middlewares/ST/STM32_ISP_Library/evision/Lib/: libn6-evision-awb_iar.a libn6-evision-st-ae_iar.a
  group Utilities
    ../../../../../../Utilities/lcd/: stm32_lcd.c
