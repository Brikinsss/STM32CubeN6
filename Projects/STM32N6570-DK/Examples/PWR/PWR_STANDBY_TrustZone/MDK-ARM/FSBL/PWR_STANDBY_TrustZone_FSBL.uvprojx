# Keil uVision project PWR_STANDBY_TrustZone_FSBL.uvprojx, settings and files
target PWR_STANDBY_TrustZone_FSBL (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: IRAM(0x341C0000-0x341FFFFF) IROM(0x34180400-0x341C03FF) CLOCK(8000000) FPU3(DFPU) CPUTYPE("Cortex-M55") ELITTLE TZ DSP
  output: Project +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32N657xx,USE_FULL_ASSERT,USE_FULL_LL_DRIVER,NO_OTP_FUSE,USER_TZ_SAU_SETUP
  c include: ../../FSBL/Inc;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../../../Middlewares/ST/STM32_ExtMem_Manager;../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/boot;../../Secure_nsclib
  memory RVCT4: ROM 0x34000000 size 0x64000
  memory RVCT9: RAM 0x34064000 size 0x9c000
  scatter file: stm32n657xx_axisram2_fsbl.sct
  link misc: --import_cmse_lib_out=../../Secure_nsclib/secure_nsclib.o
  group Application/MDK-ARM
    ../: startup_stm32n657xx_fsbl.c
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../FSBL/Src/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_bsec.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_rtc.c stm32n6xx_hal_rtc_ex.c stm32n6xx_hal_xspi.c
  group Example/User
    ../../FSBL/Src/: extmem.c main.c secure_nsc.c stm32n6xx_hal_msp.c stm32n6xx_it.c
  group Middlewares/STM32_ExtMem_Manager
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/: stm32_extmem.c
  group Middlewares/STM32_ExtMem_Manager/NOR_SFDP
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp/: stm32_sfdp_data.c stm32_sfdp_driver.c
  group Middlewares/STM32_ExtMem_Manager/SAL
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal/: stm32_sal_xspi.c
software components: CMSIS:CORE 5.6.0
