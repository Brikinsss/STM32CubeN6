<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\PWR_STANDBY_Appli.ewp</path>
  </project><project>
    <path>$WS_DIR$\FSBL\PWR_STANDBY_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
