<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\XSPI_NOR_ReadWhileWrite_DTR_Appli.ewp</path>
  </project><project>
    <path>$WS_DIR$\FSBL\XSPI_NOR_ReadWhileWrite_DTR_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
