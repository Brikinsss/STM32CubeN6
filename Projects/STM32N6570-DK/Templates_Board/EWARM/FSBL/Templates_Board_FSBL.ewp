# IAR project Templates_Board_FSBL.ewp, settings and files
configuration Templates_Board_FSBL (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32N657xx; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ../../FSBL/Core/Inc; ../../../../../Drivers/STM32N6xx_HAL_Driver/Inc; ../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include; ../../../../../Drivers/BSP/STM32N6570-DK; ../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Include; ../../../../../Drivers/STM32N6xx_HAL_Driver/Src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Templates_Board_FSBL.bin
  ILINK.IlinkOutputFile: Templates_Board_FSBL.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram2_fsbl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32n657xx_fsbl.s
  group Application/User/FSBL/Core
    ../../FSBL/Core/Src/: main.c stm32n6xx_it.c stm32n6xx_hal_msp.c
  group Drivers/BSP/STM32N6570-DK
    ../../../../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c
  group Drivers/CMSIS
    ../../FSBL/Core/Src/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_ll_exti.c stm32n6xx_hal_rif.c stm32n6xx_hal_adc.c stm32n6xx_hal_adc_ex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_cortex.c stm32n6xx_hal.c stm32n6xx_hal_exti.c stm32n6xx_ll_rcc.c stm32n6xx_ll_utils.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_mdf.c stm32n6xx_hal_sai.c stm32n6xx_hal_sai_ex.c stm32n6xx_hal_sd.c stm32n6xx_hal_sd_ex.c stm32n6xx_ll_sdmmc.c stm32n6xx_hal_mmc.c stm32n6xx_hal_mmc_ex.c stm32n6xx_hal_sdio.c stm32n6xx_ll_ucpd.c stm32n6xx_ll_gpio.c stm32n6xx_ll_dma.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c stm32n6xx_hal_hcd.c stm32n6xx_ll_usb.c stm32n6xx_hal_xspi.c
  group Doc
    ../../: README.md
