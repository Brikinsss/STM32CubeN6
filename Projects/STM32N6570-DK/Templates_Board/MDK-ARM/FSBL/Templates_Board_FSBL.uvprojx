# Keil uVision project Templates_Board_FSBL.uvprojx, settings and files
target Templates_Board_FSBL (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: IRAM(0x341C0000-0x341FFFFF) IROM(0x34180400-0x341BFFFF) CLOCK(8000000) FPU3(DFPU) CPUTYPE("Cortex-M55") ELITTLE TZ DSP
  output: Templates_Board_FSBL +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32N657xx,USE_FULL_LL_DRIVER
  c include: ../../FSBL/Core/Inc;../../../../../Drivers/BSP/STM32N6570-DK;../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x34180400 size 0x3fc00
  memory RVCT9: RAM 0x341c0000 size 0x40000
  scatter file: stm32n657xx_axisram2_fsbl.sct
  group Application/MDK-ARM
    ../: startup_stm32n657xx_fsbl.c
  group Application/User/FSBL/Core
    ../../FSBL/Core/Src/: main.c stm32n6xx_it.c stm32n6xx_hal_msp.c
  group Doc
    ../../: README.md
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_ll_usb.c stm32n6xx_ll_exti.c stm32n6xx_hal_rif.c stm32n6xx_hal_adc.c stm32n6xx_hal_adc_ex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_cortex.c stm32n6xx_hal.c stm32n6xx_hal_exti.c stm32n6xx_ll_rcc.c stm32n6xx_ll_utils.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_icache.c stm32n6xx_hal_mdf.c stm32n6xx_hal_sai.c stm32n6xx_hal_sai_ex.c stm32n6xx_hal_sd.c stm32n6xx_hal_sd_ex.c stm32n6xx_ll_sdmmc.c stm32n6xx_hal_mmc.c stm32n6xx_hal_mmc_ex.c stm32n6xx_ll_ucpd.c stm32n6xx_ll_gpio.c stm32n6xx_ll_dma.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c stm32n6xx_hal_hcd.c stm32n6xx_hal_xspi.c
  group Drivers/CMSIS
    ../../FSBL/Core/Src/: system_stm32n6xx_fsbl.c
  group Drivers/BSP/STM32N6570-DK
    ../../../../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c
software components: CMSIS:CORE 5.6.0
