<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\Ux_Device_CDC_ACM_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
