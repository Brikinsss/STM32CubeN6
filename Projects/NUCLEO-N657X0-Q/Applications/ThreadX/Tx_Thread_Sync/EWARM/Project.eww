<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\Tx_Thread_Sync_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
