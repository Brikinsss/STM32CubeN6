<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\I2C_TwoBoards_MasterTx_SlaveRx_Init_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
