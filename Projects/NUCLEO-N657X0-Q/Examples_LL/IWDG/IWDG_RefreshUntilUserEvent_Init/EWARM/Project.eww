<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\IWDG_RefreshUntilUserEvent_Init_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
