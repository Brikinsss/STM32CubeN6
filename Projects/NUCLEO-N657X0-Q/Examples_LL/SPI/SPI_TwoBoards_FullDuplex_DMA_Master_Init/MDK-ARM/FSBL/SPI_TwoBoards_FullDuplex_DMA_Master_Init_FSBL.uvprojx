# Keil uVision project SPI_TwoBoards_FullDuplex_DMA_Master_Init_FSBL.uvprojx, settings and files
target SPI_TwoBoards_FullDuplex_DMA_Master_Init_FSBL (6140001::V6.14.1::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  cpu: IRAM(0x341C0000-0x341FFFFF) IROM(0x34180400-0x341BFFFF) CLOCK(8000000) FPU3(DFPU) CPUTYPE("Cortex-M55") ELITTLE TZ DSP
  output: SPI_TwoBoards_FullDuplex_DMA_Master_Init_FSBL +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32N657xx,USE_FULL_LL_DRIVER,HSE_VALUE=48000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,MSI_VALUE=16000000,HSI_VALUE=64000000,LSI_VALUE=32000,VDD_VALUE=3300
  c include: ../../FSBL/Inc;../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x34180400 size 0x3fc00
  memory RVCT9: RAM 0x341C0000 size 0x40000
  scatter file: stm32n657xx_axisram2_fsbl.sct
  group Application/MDK-ARM
    ../: startup_stm32n657xx_fsbl.c
  group Application/User/FSBL
    ../../FSBL/Src/: main.c stm32n6xx_it.c
  group Doc
    ../../: README.md
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_ll_exti.c stm32n6xx_ll_gpio.c stm32n6xx_ll_dma.c stm32n6xx_ll_rcc.c stm32n6xx_ll_utils.c stm32n6xx_ll_spi.c stm32n6xx_ll_pwr.c
  group Drivers/CMSIS
    ../../FSBL/Src/: system_stm32n6xx_fsbl.c
software components: CMSIS:CORE 5.6.0
