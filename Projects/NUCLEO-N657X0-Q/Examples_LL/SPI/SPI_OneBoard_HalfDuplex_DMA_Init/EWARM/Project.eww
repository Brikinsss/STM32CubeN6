<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\SPI_OneBoard_HalfDuplex_DMA_Init_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
