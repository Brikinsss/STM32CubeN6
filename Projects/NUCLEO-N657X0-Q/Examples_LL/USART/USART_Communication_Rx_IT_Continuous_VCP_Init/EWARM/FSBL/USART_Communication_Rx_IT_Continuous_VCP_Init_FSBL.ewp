# IAR project USART_Communication_Rx_IT_Continuous_VCP_Init_FSBL.ewp, settings and files
configuration USART_Communication_Rx_IT_Continuous_VCP_Init_FSBL (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 0
  General.FPU2: 6
  ICCARM.CCDefines: STM32N657xx; USE_FULL_LL_DRIVER; HSE_VALUE=48000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; EXTERNAL_CLOCK_VALUE=12288000; MSI_VALUE=16000000; HSI_VALUE=64000000; LSI_VALUE=32000; VDD_VALUE=3300
  ICCARM.CCIncludePath2: ../../FSBL/Inc; ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include; ../../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USART_Communication_Rx_IT_Continuous_VCP_Init_FSBL.bin
  ILINK.IlinkOutputFile: USART_Communication_Rx_IT_Continuous_VCP_Init_FSBL.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram2_fsbl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32n657xx_fsbl.s
  group Application/User/FSBL
    ../../FSBL/Src/: main.c stm32n6xx_it.c
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../FSBL/Src/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_ll_exti.c stm32n6xx_ll_gpio.c stm32n6xx_ll_usart.c stm32n6xx_ll_rcc.c stm32n6xx_ll_dma.c stm32n6xx_ll_utils.c stm32n6xx_ll_pwr.c
