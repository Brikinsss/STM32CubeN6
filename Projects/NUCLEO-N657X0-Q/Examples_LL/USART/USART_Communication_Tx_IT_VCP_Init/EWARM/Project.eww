<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\USART_Communication_Tx_IT_VCP_Init_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
