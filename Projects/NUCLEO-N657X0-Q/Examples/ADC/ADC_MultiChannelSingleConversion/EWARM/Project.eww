<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\ADC_MultiChannelSingleConversion_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
