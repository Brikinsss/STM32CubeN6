<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\SPI_FullDuplex_CrcComIT_Slave_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
