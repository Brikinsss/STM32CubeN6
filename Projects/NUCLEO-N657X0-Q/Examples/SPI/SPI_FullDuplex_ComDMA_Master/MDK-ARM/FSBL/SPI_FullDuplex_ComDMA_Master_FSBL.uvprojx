# Keil uVision project SPI_FullDuplex_ComDMA_Master_FSBL.uvprojx, settings and files
target SPI_FullDuplex_ComDMA_Master_FSBL (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  cpu: IRAM(0x341C0000-0x341FFFFF) IROM(0x34180400-0x341BFFFF) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: SPI_FullDuplex_ComDMA_Master_FSBL +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32N657xx
  c include: ../../FSBL/Inc;../../../../../../../Drivers/BSP/STM32N6xx_Nucleo;../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy;../../../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x34180400 size 0x3fc00
  memory RVCT6: ROM 0x24000000 size 0x3e0000
  memory RVCT7: ROM 0x25000000 size 0x1000000
  memory RVCT8: ROM 0x28000000 size 0x8000
  memory RVCT9: RAM 0x341c0000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x40000
  scatter file: stm32n657xx_axisram2_fsbl.sct
  group Application/MDK-ARM
    ../: startup_stm32n657xx_fsbl.c
  group Application/User/FSBL
    ../../FSBL/Src/: main.c stm32n6xx_it.c stm32n6xx_hal_msp.c
  group Doc
    ../../: README.md
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal_cortex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal.c stm32n6xx_hal_exti.c stm32n6xx_hal_spi.c stm32n6xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../../FSBL/Src/: system_stm32n6xx_fsbl.c
  group Drivers/BSP/STM32N6xx_Nucleo
    ../../../../../../../Drivers/BSP/STM32N6xx_Nucleo/: stm32n6xx_nucleo.c
software components: CMSIS:CORE 5.6.0
