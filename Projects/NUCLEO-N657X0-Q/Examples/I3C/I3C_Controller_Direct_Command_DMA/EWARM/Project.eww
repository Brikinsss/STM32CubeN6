<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\I3C_Controller_Direct_Command_DMA_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
