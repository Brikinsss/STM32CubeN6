<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\I3C_Sensor_Private_Command_IT_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
