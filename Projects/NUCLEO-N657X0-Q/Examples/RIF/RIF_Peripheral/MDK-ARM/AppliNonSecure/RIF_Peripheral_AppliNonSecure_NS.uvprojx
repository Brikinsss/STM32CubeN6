# Keil uVision project RIF_Peripheral_AppliNonSecure_NS.uvprojx, settings and files
target RIF_Peripheral_AppliNonSecure (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.0.1.2
  cpu: IRAM(0x20040000-0x200BFFFF) IROM(0x08080000-0x80FFFFF) CLOCK(8000000) FPU3(DFPU) CPUTYPE("Cortex-M55") ELITTLE TZ DSP
  output: RIF_Peripheral_AppliNonSecure +hex
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32N657xx
  c include: ../../AppliNonSecure/Inc;../../../../../../../Drivers/BSP/STM32N6xx_Nucleo;../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy;../../../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x241a0000 size 0x20000
  memory RVCT9: RAM 0x241c0000 size 0x40000
  scatter file: stm32n657xx_LRUN_ns.sct
  link misc: ./../../Secure_nsclib/secure_nsclib.o
  group Application/MDK-ARM
    ../: startup_stm32n657xx.c
  group Application/User/AppliNonSecure
    ../../AppliNonSecure/Src/: main.c stm32n6xx_it.c stm32n6xx_hal_msp.c
  group Doc
    ../../: README.md
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal_cortex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal.c stm32n6xx_hal_exti.c
  group Drivers/CMSIS
    ../../AppliNonSecure/Src/: system_stm32n6xx_ns.c
software components: CMSIS:CORE 5.6.0
