<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\HASH_HMAC_SHA2_384_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
