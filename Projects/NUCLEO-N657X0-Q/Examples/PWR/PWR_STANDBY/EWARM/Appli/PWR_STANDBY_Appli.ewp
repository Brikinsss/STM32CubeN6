# IAR project PWR_STANDBY_Appli.ewp, settings and files
configuration PWR_STANDBY_Appli (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx; USE_FULL_ASSERT; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\..\Appli\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\..\..\..\..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\BSP\STM32N6xx_Nucleo; ../../Secure_nsclib; ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: PWR_STANDBY_Appli.out
  ILINK.IlinkIcfFile: stm32n657xx_LRUN.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User/Appli
    ../../Appli/Src/: main.c stm32n6xx_it.c stm32n6xx_hal_msp.c secure_nsc.c
  group Doc
    ../../: README.md
  group Drivers/BSP/STM32N6xx_Nucleo
    ../../../../../../../Drivers/BSP/STM32N6xx_Nucleo/: stm32n6xx_nucleo.c
  group Drivers/CMSIS
    ../: startup_stm32n657xx.s
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/iar/: startup_stm32n657xx_fsbl.s
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/: system_stm32n6xx_fsbl.c
    ../../Appli/Src/: system_stm32n6xx_s.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal_rtc.c stm32n6xx_hal_rtc_ex.c stm32n6xx_hal_cortex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal.c stm32n6xx_hal_exti.c
  group Example
    ../../Appli/Src/: main.c stm32n6xx_hal_msp.c stm32n6xx_it.c
