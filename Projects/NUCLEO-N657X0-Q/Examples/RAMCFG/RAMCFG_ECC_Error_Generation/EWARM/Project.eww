<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\RAMCFG_ECC_Error_Generation_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
